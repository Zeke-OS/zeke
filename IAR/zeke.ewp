# IAR project zeke.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F051x8 ST STM32F051x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F0XX
  ICCARM.CCIncludePath2: ..\Libraries\STM32F0xx\CMSIS; ..\Libraries\STM32F0xx\Drivers\inc; ..\Libraries\Discovery; ..\src; ..\src\hal; ..\include; ..\config
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: zeke.srec
  ILINK.IlinkOutputFile: zeke.out
  ILINK.IlinkIcfFile: C:\Repos\zeke\config\stm32f051x8.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
  group (top)
    ../: app_main.c
    ../include/: app_main.h kernel.h syscall.h
    ../src/: heap.c heap.h kernel.c kernel_init.c sched.c sched.h syscall.c thread.c thread.h timers.c timers.h
  group Config
    ../config/: kernel_config.h
  group hal
    ../src/hal/: cortex_m.c cortex_m.h hal_core.h hal_mcu.h stm32f0_interrupt.c stm32f0_interrupt.h
  group hal/CMSIS
    ../Libraries/STM32F0xx/CMSIS/: startup_stm32f0xx.s stm32f0xx.h stm32f0xx_conf.h system_stm32f0xx.c system_stm32f0xx.h
  group hal/Discovery
    ../Libraries/Discovery/: stm32f0_discovery.c stm32f0_discovery.h
  group hal/Drivers
    ../Libraries/STM32F0xx/Drivers/src/: stm32f0xx_adc.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
