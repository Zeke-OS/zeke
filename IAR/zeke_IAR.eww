<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\zeke_STM32F0.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\zeke_STR912F.ewp</path>
  </project>
  <batchBuild/>
</workspace>


