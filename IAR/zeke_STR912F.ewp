# IAR project zeke_STR912F.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STR912FAx44 ST STR912FAx44
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\src; ..\src\hal; ..\include; ..\config
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: zeke.srec
  ILINK.IlinkOutputFile: zeke.out
  ILINK.IlinkIcfFile: C:\Repos\zeke\config\stm32f051x8.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
  group (top)
    ../: app_main.c
    ../include/: app_main.h kernel.h syscall.h
    ../src/: heap.c heap.h kernel.c kernel_init.c sched.c sched.h syscall.c thread.c thread.h timers.c timers.h
  group Config
    ../config/: kernel_config.h
  group hal
    ../src/hal/: cortex_m.c cortex_m.h hal_core.h hal_mcu.h stm32f0_interrupt.c stm32f0_interrupt.h
